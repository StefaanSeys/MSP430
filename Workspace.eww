<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Accurate VLO\Accurate VLO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Autofill\Autofill.ewp</path>
  </project>
  <batchBuild/>
</workspace>


